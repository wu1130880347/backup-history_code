# IAR project boot1_stm32f4xx.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F405RG ST STM32F405RG
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: STM32F40_41xxx; USE_STDPERIPH_DRIVER; _DLIB_FILE_DESCRIPTOR
  ICCARM.CCIncludePath2: ..\User; ..\System\Delay; ..\System\Startup; ..\System\Sys; ..\Driver\Inc; ..\Fwlib\Inc; ..\System
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  OBJCOPY.OOCOutputFile: boot1_stm32f4xx20190712.bin
  ILINK.IlinkOutputFile: boot1_stm32f4xx.out
  ILINK.IlinkIcfFile: System\stm32f405xG.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  ICCARM.IccLang: 0
  group driver
    Driver/Src/: led.c usart.c
  group system
    System/Delay/: delay.c
    Fwlib/Src/: misc.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_usart.c
    System/Startup/: startup_stm32f40_41xxx.s
    System/: stm32f4xx_it.c system_stm32f4xx.c
    System/Sys/: sys.c
  group user
    User/: boot1.c main.c
