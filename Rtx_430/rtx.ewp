# IAR project rtx.ewp, settings and files
configuration Debug (MSP430, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\lib\dlib\dl430fn.h
  General.OGChipSelectMenu: MSP430F149 MSP430F149
  General.GStackSize2: 80
  General.GHeapSize2: 80
  General.RadioHeapSizeType: 0
  ICC430.CCOptLevel: 1
  ICC430.CCOptStrategy: 0
  ICC430.IccLang: 0
  XLINK.XclFile: $TOOLKIT_DIR$\config\linker\lnk430f149.xcl
  XLINK.XlinkStackSize: 1
configuration Release (MSP430)
  as the first configuration, except:
  General.RTConfigPath: xxx.h
  ICC430.CCDefines: NDEBUG
  ICC430.CCOptLevel: 3
  ICC430.ADefines: NDEBUG
  XLINK.XclFile: lnk0t.xcl
  group DRIVER/Clock
    ./: Clock.c Clock.h
  group DRIVER/PID
    ./: pid.c pid.h
  group DRIVER/SOURCE
    ./: Source.c Source.h
  group LCD12864
    ./: font.h lcd12864.c lcd_12864.h
  group RTX430
    ./: Rtx430.c Rtx430.h Rtx_in.s43
  group TASK
    ./: Task.c Task.h
  group USE
    ./: Interrupt.c main.c
