# IAR project stm32f4xx_405_demo.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F405RG ST STM32F405RG
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: STM32F40_41xxx; USE_STDPERIPH_DRIVER; _DLIB_FILE_DESCRIPTOR; SYSTEM_SUPPORT_OS
  ICCARM.CCIncludePath2: ..\System; ..\System\Delay; ..\System\Startup; ..\System\Sys; ..\Fwlib\Inc; ..\App\C_Inc; ..\Device\Inc; ..\FreeRTOS\include; ..\FreeRTOS\portable\RVDS\ARM_CM4F; ..\App\Network_Arch; ..\Driver\Usart
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  AARM.ADefines: STM32F40_41xxx
  AARM.AUserIncludes: ..\FreeRTOS\include; ..\System\Sys; ..\System
  OBJCOPY.OOCOutputFile: stm32f4xx_405_demo_20190712.bin
  ILINK.IlinkOutputFile: stm32f4xx_405_demo.out
  ILINK.IlinkIcfFile: ..\System\stm32f405xG.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  ICCARM.IccLang: 0
  group App
    ../App/C_Src/: main.cpp
  group Device
    ../Device/Src/: led.c
  group Driver
    ../Driver/Usart/: usart.c
  group FreeRTOS
    ../FreeRTOS/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
  group FreeRTOS/port
    ../FreeRTOS/portable/MemMang/: heap_4.c
    ../FreeRTOS/portable/RVDS/ARM_CM4F/: port.c portasm.s
  group Fwlib
    ../Fwlib/Src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group NetArch
    ../App/Network_Arch/: CNetManagement.cpp CTool.cpp CUartProtocol.cpp CUdpProtocol.cpp driver.cpp Hmac_sha1.cpp IGPRS.cpp IRJ45.cpp IUarts.cpp
  group System
    ../System/Delay/: delay.c
    ../System/Startup/: startup_stm32f40_41xxx.s
    ../System/: stm32f4xx_it.c system_stm32f4xx.c
    ../System/Sys/: sys.c
