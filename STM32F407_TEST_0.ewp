# IAR project STM32F407_TEST_0.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F415RG ST STM32F415RG
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: STM32F40_41xxx; USE_STDPERIPH_DRIVER; __MAIN_H
  ICCARM.CCIncludePath2: ; USER\; CMSIS\; FWLIB\src\; FWLIB\inc\; DRIVER\mpu6050\; DRIVER\; DRIVER\my_os\; DRIVER\LCD\; DRIVER\tft3_2\; DRIVER\usb_sd\; DRIVER\mpu6050\eMPL\; CMSIS\sys\; CMSIS\delay\; CMSIS\usart\
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: STM32F407_TEST_0.txt
  ILINK.IlinkOutputFile: STM32F407_TEST_0.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  group CMSIS/delay
    CMSIS/delay/: delay.c delay.h
  group CMSIS/startup
    CMSIS/STARTUP/: startup_stm32f40_41xxx.s
  group CMSIS/sys
    CMSIS/sys/: sys.c sys.h
  group CMSIS/system
    CMSIS/: stm32f4xx.h system_stm32f4xx.c system_stm32f4xx.h
  group CMSIS/usart
    CMSIS/usart/: usart.c usart.h
  group DRIVER
    DRIVER/: Driver.c Driver.h ProHead.h
  group DRIVER/24L01
    DRIVER/: 24l01.c 24l01.h rf24L01.h
  group DRIVER/ADC_12
    DRIVER/: adc.c adc.h
  group DRIVER/ADXL345
    DRIVER/: adxl345.c adxl345.h
  group DRIVER/DAC
    DRIVER/: dac.c dac.h
  group DRIVER/DS1302
    DRIVER/: ds1302.c ds1302.h
  group DRIVER/ds18b20
    DRIVER/: ds18b20.c ds18b20.h
  group DRIVER/EXTI
    DRIVER/: exti.c exti.h
  group DRIVER/KEY
    DRIVER/: key.c key.h
  group DRIVER/LCD320_240
    DRIVER/LCD/: FONT.H lcd.h
  group DRIVER/LCD_12864
    DRIVER/: font.h lcd12864.c lcd_12864.h
  group DRIVER/LED
    DRIVER/: led.c led.h
  group DRIVER/MPU6050/eMPL
    DRIVER/mpu6050/eMPL/: dmpKey.h dmpmap.h inv_mpu.c inv_mpu.h inv_mpu_dmp_motion_driver.c inv_mpu_dmp_motion_driver.h
  group DRIVER/MPU6050/mpu_driver
    DRIVER/mpu6050/: mpu6050.c mpu6050.h myiic.c myiic.h
  group DRIVER/OV7670
    DRIVER/: ov7670.c ov7670.h ov7670config.h sccb.c sccb.h
  group DRIVER/OV7725
    DRIVER/: bsp_ov7725.c bsp_ov7725.h bsp_sccb.c bsp_sccb.h
  group DRIVER/PID
    DRIVER/: pid.c pid.h
  group DRIVER/PWM
    DRIVER/: pwm.c pwm.h
  group DRIVER/RTC
    DRIVER/: rtc.c rtc.h
  group DRIVER/SOURCE
    DRIVER/: Source.c Source.h
  group DRIVER/SPI
    DRIVER/: spi.c spi.h
  group DRIVER/TFT3_2
    DRIVER/tft3_2/: ASC8x16.h fsmc_driver.c fsmc_driver.h GB2312.h lcd_driver.c lcd_driver.h lcdLib.c lcdlib.h qqImage.h
  group DRIVER/TFT3_2/TOUCH
    DRIVER/tft3_2/: Touch.c Touch.h
  group DRIVER/TIM_5
    DRIVER/: timer.c timer.h
  group DRIVER/USB_SD
    DRIVER/usb_sd/: CH376INC.H DEBUG.C DEBUG.H FILE_SYS.C FILE_SYS.H HAL.H HAL_BASE.C SPI_SW.C
  group FWLIB/inc
    FWLIB/inc/: misc.h stm32f4xx_adc.h stm32f4xx_can.h stm32f4xx_crc.h stm32f4xx_cryp.h stm32f4xx_dac.h stm32f4xx_dbgmcu.h stm32f4xx_dcmi.h stm32f4xx_dma.h stm32f4xx_dma2d.h stm32f4xx_exti.h stm32f4xx_flash.h stm32f4xx_flash_ramfunc.h stm32f4xx_fmc.h stm32f4xx_fsmc.h stm32f4xx_gpio.h stm32f4xx_hash.h stm32f4xx_i2c.h stm32f4xx_iwdg.h stm32f4xx_ltdc.h stm32f4xx_pwr.h stm32f4xx_rcc.h stm32f4xx_rng.h stm32f4xx_rtc.h stm32f4xx_sai.h stm32f4xx_sdio.h stm32f4xx_spi.h stm32f4xx_syscfg.h stm32f4xx_tim.h stm32f4xx_usart.h stm32f4xx_wwdg.h
  group FWLIB/src
    FWLIB/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group USER
    USER/: main.c main.h stm32f4xx_conf.h stm32f4xx_it.c stm32f4xx_it.h
